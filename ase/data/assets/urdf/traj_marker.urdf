Commit message: 1

File: ase/data/assets/urdf/traj_marker.urdf (robot description, URDF)
Before this commit: robot object, 1 links, 0 joints
Links:
- link object: geometry visual sphere radius=0.05
